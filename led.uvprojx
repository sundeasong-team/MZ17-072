# Keil uVision project led.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.1.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s main.c uart.c Command.c Control.c IIC.c timer.h 24C128.c delay.c IO.C uart1.c timer.c ToyoControl.c RepeatHandle.c uart2.c IIC1.c IIC2.c PCA9655E.c uart3.c Readme.txt
  group Source
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
    ./CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
software components: CMSIS:CORE 4.3.0
